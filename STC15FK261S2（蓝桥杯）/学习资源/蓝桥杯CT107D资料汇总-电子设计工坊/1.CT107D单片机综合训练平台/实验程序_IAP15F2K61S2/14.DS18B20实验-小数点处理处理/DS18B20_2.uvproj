# Keil uVision project DS18B20_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS18B20_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: STC12
  group Source Group 1
    ./: STARTUP.A51 onewire.c ex14.c
