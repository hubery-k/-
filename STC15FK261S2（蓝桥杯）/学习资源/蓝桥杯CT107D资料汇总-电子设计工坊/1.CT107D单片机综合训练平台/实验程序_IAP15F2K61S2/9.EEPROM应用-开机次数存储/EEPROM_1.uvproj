# Keil uVision project EEPROM_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: EEPROM_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: EEPROM_AT24C02
  group Source Group 1
    ./: STARTUP.A51 ex9.c i2c.c
