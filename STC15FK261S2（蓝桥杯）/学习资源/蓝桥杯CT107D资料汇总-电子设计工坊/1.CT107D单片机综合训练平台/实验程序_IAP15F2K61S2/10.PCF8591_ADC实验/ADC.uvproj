# Keil uVision project ADC.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ADC +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: ADC_PCF8591
  group Source Group 1
    ./: STARTUP.A51 i2c.c ex10.c
