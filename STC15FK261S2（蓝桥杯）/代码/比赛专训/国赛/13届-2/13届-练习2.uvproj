# Keil uVision project 13届-练习2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 13届-练习2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./: STARTUP.A51 main.c main.h Define.h
  group Hardware
    ./: HC573.c KEY.c DS18B20.c CLOCK.c Timer.c PCF8591.c AT24C02.c Delay.c Sonic.c Uart.c
  group Drive
    ./: ds1302.c iic.c onewire.c
