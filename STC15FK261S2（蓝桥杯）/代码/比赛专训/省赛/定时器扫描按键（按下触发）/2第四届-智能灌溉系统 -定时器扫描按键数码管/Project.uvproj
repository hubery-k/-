# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
  group Hardware
    ./: KEY.c LED.c EEPROM.c Nixie.c AD.c Clock.c RB.c Timer.c
  group Drive
    ./: ds1302.c ds1302.h iic.c iic.h Delay.c Delay.h
