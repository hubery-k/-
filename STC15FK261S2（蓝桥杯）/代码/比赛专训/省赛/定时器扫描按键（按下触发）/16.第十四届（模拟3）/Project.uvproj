# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Define.h
  group Hardware
    ./: KEY.c KEY.h LED.c LED.h RB.c RB.h NIXIE.c NIXIE.h PCF8591.c PCF8591.h UART.c UART.h Timer.c Timer.h
  group Drive
    ./: iic.c iic.h
