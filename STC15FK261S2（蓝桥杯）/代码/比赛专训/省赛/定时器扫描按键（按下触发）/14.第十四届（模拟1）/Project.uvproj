# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./: STARTUP.A51 main.c Define.h
  group Hardware
    ./: LED.c LED.h RB.c RB.h Nixie.c Nixie.h KEY.c KEY.h Timer.c Timer.h Sonic.c Sonic.h UART.c UART.h
  group Drive
    ./: Delay.c Delay.h
