# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./: STARTUP.A51 Define.h main.c
  group Hardware
    ./: LED.c RB.c KEY.c Nixie.c Timer.c DS18B20.c PCF8591.c CLOCK.c AT24C02.c Delay.c UART.c Sonic.c
  group Drive
    ./: ds1302.c iic.c onewire.c
