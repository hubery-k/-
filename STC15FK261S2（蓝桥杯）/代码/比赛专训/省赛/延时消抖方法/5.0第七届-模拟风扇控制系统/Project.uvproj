# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c STARTUP.A51
  group Hardware
    ./: BUZZER.c LED.c LED.h BUZZER.h RELAY.c RELAY.h Nixie.c Nixie.h DS18B20.c DS18B20.h KEY.c KEY.h PWM.c PWM.h Timer.c Timer.h
  group Drive
    ./: onewire.c onewire.h Delay.c Delay.h
