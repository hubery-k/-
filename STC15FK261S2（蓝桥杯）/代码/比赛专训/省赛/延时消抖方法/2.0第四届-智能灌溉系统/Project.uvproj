# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
  group Hardware
    ./: RELAY.c RELAY.h BUZZER.c BUZZER.h KEY.c KEY.h LED.c LED.h EEPROM.c EEPROM.h Nixie.c Nixie.h AD.c AD.h Clock.c Clock.h
  group Drive
    ./: ds1302.c ds1302.h iic.c iic.h Delay.c Delay.h
