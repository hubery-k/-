# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\BSP\inc;.\TOOL\inc
  group APP
    ./APP/: main.c
  group BSP
    ./BSP/src/: LED.c BUZZER.c RELAY.c Nixie.c KEY.c INT.c Timer.c UART.c Ds1302_Clcok.c DS18B20.c AD.c AT24C02.c NE555.c
  group TOOL
    ./TOOL/src/: Delay.c ds1302.c onewire.c iic.c
